# Repository Sparkler21/EML_NB_Logger

File README.md:

# EML_NB_Logger
Small Narrowband IoT logger for river level and rainfall measurements

NB-IoT vs LTE-M: flip USE_NBIOT (if your MKRNB core exposes setRadioAccessTechnology — some versions don’t; if absent, the network will choose based on availability/APN).

PSM/eDRX: the u-blox modem can be tuned via AT (PSM timers, eDRX). MKRNB doesn’t expose all knobs; you can still send raw AT commands with nbAccess if you want to squeeze more battery life later.

TLS: once you’re happy, switch to port 8883 and use ArduinoBearSSL with MqttClient’s secure variant (RAM is tighter but OK on MKR).

Analog scaling: set ADS1115 gain to match your sensor’s max voltage for best resolution (e.g., GAIN_TWOTHIRDS, GAIN_ONE, etc.).

Long cables: add TVS diodes and/or an opto-isolator on the rain input if cables run outdoors.

Power: with hourly uploads and deep sleep, a 2000 mAh cell will last a long time; add a small 2–5 W solar for near-infinite runtime.

## EAGLE design PCB/SD-eagle-files/MKRSDProtoshield_Rev1.1.brd

Parts:
C1: 10u; 0603-1608X90N
C2: 100n; 0603-1608X90N
FRAME1: DNP; FRAME
J1: AMPHENOL_114-00841-68
JP3, JP4: -; 1X14
JP5, JP6: PINHD-1X9; 1X09
R1, R2: 10k; C0603
U1: W28Q16; SON9P127_500X600X80L60X41T340X400N

Connections:
+3V3: C1.2, C2.1, J1.4 (VDD), JP4.12, JP6.3, R1.2, R2.1, U1.3 (/WP), U1.7 (/HOLD), U1.8 (VCC)
+5V: JP4.14, JP6.1
GND: C1.1, C2.2, J1.6 (VSS), J1.SH1 (G3), J1.SH2 (G3), J1.SH3 (G2), J1.SH4 (G2), JP4.11, JP6.4, U1.4 (GND), U1.9 (EP)
unnamed: J1.2 (CD/DAT3), JP3.13, R2.2
unnamed: J1.3 (CMD), JP4.3, U1.5 (DI)
unnamed: J1.5 (CLK), JP4.4, U1.6 (CLK)
unnamed: J1.7 (DAT0), JP4.5, U1.2 (DO)
unnamed: JP3.7, JP5.3
unnamed: JP3.6, JP5.4
unnamed: JP3.5, JP5.5
unnamed: JP3.4, JP5.6
unnamed: JP3.3, JP5.7
unnamed: JP3.2, JP5.8
unnamed: JP3.1, JP5.9
unnamed: JP4.13, JP6.2
unnamed: JP4.10, JP6.5
unnamed: JP4.9, JP6.6
unnamed: JP4.8, JP6.7
unnamed: JP4.7, JP6.8
unnamed: JP4.6, JP6.9
unnamed: JP3.8, JP5.2
unnamed: JP3.9, JP5.1
unnamed: JP3.12, R1.1, U1.1 (/CS)

Notes on the sheet:
AREF
DAC0/A0
8/MOSI
9/SCK
10/MISO
11/SDA
12/SCL
13/RX
14_TX
RESET
GND
3.3V
VIN

Board: 2 copper layers, 25.2 x 61.5 mm, 11 parts (0 on the bottom side), 23 nets.

## EAGLE design PCB/MKRNB1500-reference/MKRNB1500_V3.0.brd

Parts:
C1: 4n7; 0805-R2013X50N; VOLTAGE 1KV
C2, C6, C7: 100n; 0402-1005X55N
C3, C4: 20p; 0402-1005X55N
C5: 4u7; 0402-1005X55N
C10: 15p; 0402-1005X55N
C11: 33p; 0402-1005X55N
C33: DNP; 0402-1005X55N
D1: PRTR5V; SOT190P230X110-4N
D7: DNP; 0402-1005X55N
D+: DNP; TP-1.00MM
D-: DNP; TP-1.00MM
DL1: YELLOW; LEDC1608X80N-AK
ESCL: DNP; TP-1.00MM
ESDA: DNP; TP-1.00MM
EWK: DNP; TP-1.00MM
FRAME1: DNP; FRAME
J1: -; ZX62-AB-5PA
J2: DNP; 2X3_SMT
J3, J5: -; 1X14_SMD_TH
J4: -; SM05B-SRSS-TB
J6: -; U.FL-R-SMT-1(60)
L1: 39nH; C0402
L4: 68nH; C0402
PB1: PTS820; C&K_PTS820_NO_HOLES
Q1: 2N7002; SOTFL50P160X78-3
Q5: 2N7002DW-7-FNO_PAD; PWR_SC70-6L2
R1, R9, R10, R11, R16: 1M2; 0402-1005X55N
R2: 39R; 0402-1005X55N
R3, R6, R15: 330R; 0402-1005X55N
R4: 1k; 0402-1005X55N
R5: 10k; 0402-1005X55N
R7, R12, R17, R20, R35: DNP; 0402-1005X55N
R8: 330k; 0402-1005X55N
R13, R14: 4k7; 0402-1005X55N
R37: 0R; 0402-1005X55N
TP1, TP2, TP3: DNP; TP-1.00MM
U1: D21G18; QFN50P700X700X90-49XN-EPSQ515
U3: SARA-R4; SARA-96
U4: ECC508; SON50P300X200X60-9N-EP160X140
USB_GND: DNP; TP-1.00MM
VSUB: DNP; TP-1.00MM
Y1: 32768Hz; ABS07

Connections:
+3V3: J2.1, J5.12, R4.2, R5.2, R13.2, R14.2, R15.1; also elsewhere on the board
+5V: D1.4, J1.1, J4.1, J5.14, R12.1, VSUB.X; also elsewhere on the board
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.2, C33.2, D7.1, J1.5, J2.5, J4.5, J4.SH1 (SH), J4.SH2 (SH), J5.11, J6.GND1 (GND), J6.GND2 (GND), L1.1, PB1.1 (3), PB1.2 (3), PB1.3, PB1.4 (3), PB1.5 (1), Q1.S, Q5.1 (S), Q5.4 (S), R1.1, R9.1, R10.1, R11.1, R16.1, R35.1, USB_GND.X; also elsewhere on the board
MCTS: U3.11 (CTS); also elsewhere on the board
MDTR: R35.2, R37.2, U3.9 (DTR)
MRI: U3.7 (RI)
MRST: Q5.6 (D), U3.18 (!RESET)
MRTS: U3.10 (RTS); also elsewhere on the board
MRX: U3.13 (RXD); also elsewhere on the board
MTX: U3.12 (TXD); also elsewhere on the board
N17658775: PB1.6 (2), R3.1
unnamed: C1.1, D1.1, J1.6 (SH), J1.7 (SH), J1.8 (SH), J1.9 (SH), J1.10 (SH), J1.11 (SH), R1.2
unnamed: J2.3, R2.1
unnamed: C10.1, U3.56 (ANT)
unnamed: C6.1, R8.1, R9.2, U1.8 (PB09)
unnamed: DL1.A, R15.2
unnamed: C11.2, J6.SIG, L4.2
unnamed: R7.2, TP1.X, U3.29 (USB_D+)
unnamed: DL1.C, Q1.D
unnamed: R17.2, TP2.X, U3.28 (USB_D-)
unnamed: R12.2, TP3.X, U3.17 (V_USB_DET)
unnamed: C10.2, C11.1, L1.2
unnamed: R37.1, U3.16 (GPIO1)
unnamed: R20.1, U3.62 (ANT_DET)
unnamed: C33.1, D7.2, L4.1, R20.2
PA00_XIN32: C3.2, U1.1 (PA00/XIN32), Y1.2
PA01_XOUT32: C4.2, U1.2 (PA01/XOUT32), Y1.1
PA02_AIN0: J3.2, U1.3 (PA02)
PA03_VREFA: C5.1, C7.1, J3.1, U1.4 (PA03)
PA04_AIN4: J3.5, U1.9 (PA04)
PA05_AIN5: J3.6, U1.10 (PA05)
PA06_AIN6: J3.7, U1.11 (PA06)
PA07_AIN7: J3.8, U1.12 (PA07)
PA08_S0_I2C_SDA: ESDA.X, J4.4, J5.6, R14.1, U1.13 (PA08), U4.5 (SDA); also elsewhere on the board
PA09_S0_I2C_SCL: ESCL.X, J4.3, J5.7, R13.1, U1.14 (PA09), U4.6 (SCL); also elsewhere on the board
PA10_TCC0-W2: J3.11, U1.15 (PA10)
PA11_TCC0-W3: J3.12, U1.16 (PA11)
PA12_S2_TX: U1.21 (PA12); also elsewhere on the board
PA13_S2_RX: U1.22 (PA13); also elsewhere on the board
PA14_S2_RTS: U1.23 (PA14); also elsewhere on the board
PA15_S2_CTS: U1.24 (PA15); also elsewhere on the board
PA16_S1_MOSI: J5.3, U1.25 (PA16)
PA17_S1_SCK: J5.4, U1.26 (PA17)
PA18_OTG: J1.4, U1.27 (PA18); also elsewhere on the board
PA19_S1_MISO: J5.5, U1.28 (PA19)
PA20_TCC0-W6: J5.1, Q1.G, R16.2, U1.29 (PA20)
PA21_TCC0-W7: EWK.X, J4.2, J5.2, U1.30 (PA21)
PA22_TC4-W0: J3.9, U1.31 (PA22)
PA23_TC4-W1: J3.10, U1.32 (PA23)
PA27_INT: U1.39 (PA27); also elsewhere on the board
PA28_S2_PWRON: Q5.5 (G), R11.2, U1.41 (PA28)
PA30_SWCLK: J2.4, R4.1, U1.45 (PA30/SWCLK)
PA31_SWDIO: J2.2, U1.46 (PA31/SWDIO)
PB02_AIN10: J3.3, U1.47 (PB02)
PB03_AIN11: J3.4, U1.48 (PB03)
PB08_RST: Q5.2 (G), R10.2, U1.7 (PB08)
PB10_TCC0-W4: J3.13, U1.19 (PB10)
PB11_TCC0-W5: J3.14, U1.20 (PB11)
PB22_S5_TX: J5.9, U1.37 (PB22)
PB23_S5_RX: J5.8, U1.38 (PB23)
PWR_ON: Q5.3 (D), U3.15 (PWR_ON)
RESET#: J5.10, R6.2
RESETN: C2.1, R2.2, R3.2, R5.1, R6.1, U1.40 (RESETN)
USB_N: D1.3, D-.X, J1.2, R17.1, U1.33 (PA24/USB_DM)
USB_P: D1.2, D+.X, J1.3, R7.1, U1.34 (PA25/USB_DP)
VBATT: R8.2; also elsewhere on the board
VIN: J5.13; also elsewhere on the board

Notes on the sheet:
14 <- TX
13 -> RX
12 SCL
RESET
11 SDA
8 MOSI
9 SCK
10 MISO
AREF
DAC0/A0
Crypto Auth
Arturo Guadalupi

Parts:
BATT+: DNP; TP-1.00MM
BATT-: DNP; TP-1.00MM
C12, C13, C19, C20, C34: 10u; 0603-1608X90N
C14, C22, C25, C26: 1u; 0402-1005X55N
C15: 47n; 0402-1005X55N
C16: 4u7; 0402-1005X55N
C17, C18, C21, C23, C24, C29, C32: 100n; 0402-1005X55N
C27: 4u7; 0603-1608X90N
C28: 10n; 0402-1005X55N
C30: 15p; 0402-1005X55N
C31: 100uF; C1206
C37: 68p; 0402-1005X55N
D2, D3: DNP; SODFL3517X110N
D4, D5, D6: PESD0402; 0402-1005X55N
DL2: ORANGE; LEDC1608X80N-AK
DL3: GREEN; LEDC1608X80N-AK
FD1, FD2, FD3: DNP; FD-1-1.5
FRAME2: DNP; FRAME
J7: -; JST-S2B-PH-SM4-TB
L2: 2u2; SRP4020
L3: BLM18PG471; 0603-1608X90N
Q2: SIA817; SON65P205X205X75-8N-MWSD
Q3, Q4: 2N7002; SOTFL50P160X78-3
R19, R21, R24, R25, R26, R31, R32: 1M2; 0402-1005X55N
R23, R28: 330R; 0402-1005X55N
R27: 390R; 0402-1005X55N
R29: 10k; 0402-1005X55N
R30: 5k49; 0402-1005X55N
SIM1: -; MICROSIM8
U1: D21G18; QFN50P700X700X90-49XN-EPSQ515
U3: SARA-R4; SARA-96
U4: ECC508; SON50P300X200X60-9N-EP160X140
U5: BQ24195L; QFN24
U7: AP2112K-3.3; SOT25

Connections:
+1V8: R31.2, R32.2, U3.4 (V_INT); also elsewhere on the board
+3V3: C17.1, C18.1, C21.1, C24.1, C26.1, L3.1, R21.1, R24.1, R26.1, U1.17 (VDDIO), U1.36 (VDDIO), U1.44 (VDDIN), U4.8 (VCC), U7.5 (OUT); also elsewhere on the board
+3V8: C19.1, C20.1, C22.1, C28.1, C29.1, C30.1, C31.1, C34.1, C37.1, L2.2, R23.2, U3.51 (VCC), U3.52 (VCC), U3.53 (VCC), U5.15 (SYS), U5.16 (SYS), U7.1 (IN), U7.3 (EN)
+5V: D3.C, Q2.D, Q2.D2 (D); also elsewhere on the board
GND: BATT-.X, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C34.2, C37.2, D2.A, D4.1, D5.1, D6.1, DL3.C, J7.2, J7.3 (SH), J7.4 (SH), Q3.S, Q4.S, R19.1, R25.1, R28.2, R29.1, SIM1.GND, SIM1.SH1 (GND), SIM1.SH2 (GND), SIM1.SH3 (GND), SIM1.SH4 (GND), SIM1.SH5 (GND), U1.5 (GNDANA), U1.18 (GND), U1.35 (GND), U1.42 (GND), U1.49 (EP), U3.1 (GND), U3.3 (GND), U3.5 (GND), U3.14 (GND), U3.20 (GND), U3.21 (GND), U3.22 (GND), U3.30 (GND), U3.32 (GND), U3.33 (RSVD), U3.43 (GND), U3.50 (GND), U3.54 (GND), U3.55 (GND), U3.57 (GND), U3.58 (GND), U3.59 (GND), U3.60 (GND), U3.61 (GND), U3.63 (GND), U3.64 (GND), U3.65 (GND), U3.66 (GND), U3.67 (GND), U3.68 (GND), U3.69 (GND), U3.70 (GND), U3.71 (GND), U3.72 (GND), U3.73 (GND), U3.74 (GND), U3.75 (GND)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; also elsewhere on the board
N17798864: DL2.A, R23.1
N17834267: DL3.A, R27.1
N17852357: C23.1, C27.1, L3.2, U1.6 (VDDANA)
N17852431: C25.1, U1.43 (VDDCORE)
unnamed: Q4.D, R32.1, U3.42 (SIM_DET)
unnamed: C15.2, L2.1, U5.19 (SW), U5.20 (SW)
unnamed: C14.1, Q2.K (C), Q2.K2 (C), Q2.S, R27.2, U5.1 (VBUS), U5.24 (VBUS)
unnamed: C15.1, U5.21 (BTST)
unnamed: R28.1, U5.10 (ILIM)
unnamed: C16.1, R30.1, U5.22 (REGN)
unnamed: Q3.D, R26.2, U5.8 (OTG)
unnamed: R29.2, R30.2, U5.11 (TS1), U5.12 (TS2)
unnamed: R25.2, U5.9 (CE)
PA08_S0_I2C_SDA: U5.6 (SDA); also elsewhere on the board
PA09_S0_I2C_SCL: U5.5 (SCL); also elsewhere on the board
PA18_OTG: Q3.G, R21.2; also elsewhere on the board
PA27_INT: R24.2, U5.7 (INT); also elsewhere on the board
SCLK: D5.2, SIM1.CLK, U3.38 (SIM_CLK)
SIO: D6.2, SIM1.IO (I/O), U3.39 (SIM_IO)
SRST: D4.2, SIM1.RST, U3.40 (SIM_RST)
SSW: Q4.G, R31.1, SIM1.SW
STAT: DL2.C, U5.4 (STAT)
SVCC: C32.2, SIM1.VCC, U3.41 (VSIM)
VBATT: BATT+.X, D2.C, J7.1, U5.13 (BAT), U5.14 (BAT); also elsewhere on the board
VIN: Q2.A, Q2.G, R19.2; also elsewhere on the board
VUSB1: C12.1, C13.1, D3.A, U5.23 (PMID)
V_BCKP: U3.2 (V_BCKP)

Notes on the sheet:
Arturo Guadalupi

Board: 4 copper layers, 67.5 x 24.9 mm, 127 parts (40 on the bottom side), 88 nets.

Other parts of the board:
C101, C102: 1u; 0402-1005X55N
FRAME101: DNP; FRAME
U101, U102, U103, U104: 74LVC145T; DCK
U$5, U$6, U$7, U$8: MH_RND_F_2.2MM_NM

Their connections:
+1V8: C102.1, U101.6, U102.6, U103.6, U104.6; also elsewhere on the board
+3V3: C101.1, U101.1, U102.1, U103.1, U103.5, U104.1, U104.5; also elsewhere on the board
GND: C101.2, C102.2, U101.2, U101.5, U102.2, U102.5, U103.2, U104.2; also elsewhere on the board
MCTS: U102.4; also elsewhere on the board
MRTS: U103.4; also elsewhere on the board
MRX: U101.4; also elsewhere on the board
MTX: U104.4; also elsewhere on the board
PA12_S2_TX: U104.3; also elsewhere on the board
PA13_S2_RX: U101.3; also elsewhere on the board
PA14_S2_RTS: U103.3; also elsewhere on the board
PA15_S2_CTS: U102.3; also elsewhere on the board

## Commit log

2025-10-06 First version
2025-10-08 Added RTC TimeStamp that will replace the TB timestamp.
2025-10-08 Gone back to basics. Remove timestamp. Now AT Modem SIM problems.
2025-10-10 Back to basics. Simple working MQTT protocol code.
2025-10-10 Problems with NTP and timestamp.
2025-10-13 Playing about with RTC alarms.
2025-10-24 Work done in Vienna and Vancouver on sensor sampling.
2025-10-24 Problems with RTC alarms.
2025-10-28 Full rewrite. Currently having problesm with modTest (Modulus) but think it might be when the ADC is disconnected.
2025-10-29 Logging seems okay. Need to add MQTT and Send msg.
2025-10-30 MQTT, NTP and Sampling working. Need 24hr reset functions, Modes and testing.
2025-10-30 Removed Library back ups
2025-10-30 Added LED (5 flash on connect, 1 long flash on send) and internal ADC sampling of river level on A1.
2025-10-31 Full working system without WDT or Self-Recovery.
2025-10-31 Testing River Level.
2025-11-03 Deep Sleep mode and battery testing.
2025-11-04 MOved LED setup earlier.
2025-11-06 Lots of error checking added. Needs a lot of cleaning up when working.
2025-11-10 Added loads of ChatGPT connection PDP/NTP/HTTP stuff and it has not helped.
2025-11-10 Back to earlier version: Deep Sleep mode and battery testing.
2025-11-10 Working on a simply connection routine with ChapGPT.
2025-11-11 New build. MQTT working. Sensors working. No time yet.
2025-11-11 Starting to try and solve the dreaded NTP sync problem.
2025-11-12 Added SD Card but not tested.
2025-11-13 SD Working. Now adding configuration file.
2025-11-13 SD Card configs not working yet. Lots of added code since earlier.
2025-11-14 Added LED and full SD Card configuration. Still no time back up.
2025-11-14 Moved LED flashing as it altered sampling times.
2025-11-14 Testing WatchDog Timer and Time logging issues.
2025-11-19 Added GPS module and removed NTP. Still getting strange resets occasionally.
2025-11-19 Removed GPRS and altered battery volt sampling. Still checking.
2025-11-25 Added modem sleep and other sleep items from CGPT. Not working yet.
2025-11-26 Reverted back 5 days after failed power saving with CGPT.
2025-11-26 Now doing NB before GPS. Seems more stable.
2025-12-01 Working code with correct VBatt sampling. Still need to smooth out initial NB and GPS connections.
2025-12-16 Final Code and Settings.
2026-01-11 Working on more robust set-up and MQTT connection.
2026-01-14 Brought accross MinStable setup to NB_Logger set-up and now trying to merge.
2026-01-21 Basic stable code complete. Now to work on lower power.
2026-01-21 Deleted unused code. Added in sleep functions (not tested).
2026-01-22 Still working on low power solution.
2026-01-23 Simplified to try and get power down. Now on 10min wake up and not 1min. Still problems waking up modem.
2026-01-26 Still trying to solve connection and power issues.
2026-01-27 Still struggling with nbAccess.

Notices in the files:
PCB/MKRNB1500-reference/MKRNB1500_V3.0.brd:
Copyright (c) 2016-2017 Arduino LLC.  All right reserved. EAGLE Design Rules
parts and their libraries:
Arduino-ucs: Copyright (c) 2016-2017 Arduino LLC.  All right reserved.
Arduino-utility: This file is licensed under : CC-SA-BY-NC
